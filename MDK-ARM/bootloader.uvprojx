# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32F401xC
  c include: ..\Inc;..\bsp\Drivers\STM32F4xx_HAL_Driver\Inc;..\bsp\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\bsp\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\bsp\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\bsp\Middlewares\Third_Party\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../Src/: startup_stm32f401xc.s
  group Drivers/STM32F4xx_HAL_Driver
    ../bsp/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_hcd.c
  group Middlewares/USB_Host_library
    ../bsp/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../bsp/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/FatFS/Core
    ../bsp/Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../bsp/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group src
    ../Src/: usart.c system_stm32f4xx.c main.c retarget.c gpio.c stm32f4xx_it.c lcd.c usbh_conf.c usbh_diskio_dma.c boot.c db.c crc.c
software components: CMSIS:CORE 5.2.0
